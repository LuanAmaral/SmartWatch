## components/pulse_oximeter/Kconfig
```kconfig
menu "Oximeter and Pulse Rate component"
    # TODO: Add a configuration
endmenu
```
